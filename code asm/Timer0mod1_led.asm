ORG 0000H
    SJMP MAIN

ORG 000BH
	JMP TIMER0_ISR
ORG 0030H
MAIN:
	MOV TMOD, #01H 
	MOV TH0, #3CH 
	MOV TL0, #0B0H 
	
	MOV R7, #10
	
	SETB ET0 
	SETB EA 
	SETB P2.1 
	SETB TR0 
LOOP:
	JMP LOOP
TIMER0_ISR: 
	MOV TH0, #3CH 
	MOV TL0, #0B0H 
	DJNZ R7, EXIT_ISR
	MOV R7, #10 
	CPL P2.1

EXIT_ISR:
	RETI
END