ORG 0000H

BEGIN_ENTRY: 
	SETB P2.0
	SETB P2.1
	SETB P2.2
    SETB P2.3 ; LED tat
	SETB P2.4
	SETB P2.5
	SETB P2.6
	SETB P2.7
	
MAIN_LOOP:
	CPL P2.0
	CPL P2.1
	CPL P2.2	
    CPL P2.3 ; LED dao
	CPL P2.4
	CPL P2.5
	CPL P2.6	
	CPL P2.7
    LCALL DELAY200ms
    SJMP MAIN_LOOP

DELAY1S:
    MOV R3, #5
S1BACK:
    LCALL DELAY200ms
    DJNZ R3, S1BACK
    RET

DELAY200ms:
    MOV R2, #200

LAP2:
    MOV R1, #200
LAP1:
    NOP
    NOP
    NOP
    DJNZ R1, LAP1
    DJNZ R2, LAP2
    RET

END
