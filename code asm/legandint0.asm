SEGMENT_PORT EQU P0     
VALUE        DATA 30H     

ORG 0000H
    SJMP MAIN
ORG 0003H
	LJMP INT0_ISR
	
MAIN:
    MOV VALUE, #00H   
	SETB IT0 
	SETB EX0
	SETB EA 
	
MAIN_LOOP:
    SJMP MAIN_LOOP	
INT0_ISR:
	INC VALUE
	MOV A, VALUE
    CJNE A, #0AH, DISPLAY
    MOV VALUE, #00H
DISPLAY:
    MOV DPTR, #TABLE
    MOV A, VALUE
    MOVC A, @A+DPTR      
    MOV SEGMENT_PORT, A  
    MOV P2, VALUE       
    RETI      

TABLE:
    DB 03FH
    DB 006H
    DB 05BH
    DB 04FH
    DB 066H
    DB 06DH
    DB 07DH
    DB 007H
    DB 07FH
    DB 06FH

END
