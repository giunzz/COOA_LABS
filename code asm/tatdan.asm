ORG 0000H

BEGIN_ENTRY:
    MOV A, #00H     ; 0000 0000   

MAIN_LOOP:
    
    RL A
	ORL A, #01H
	
	MOV P2, A        
    LCALL DELAY200ms
	
    CJNE A, #0FFH, CONT 
    MOV A, #00H

CONT:
    SJMP MAIN_LOOP

DELAY1S:
    MOV R3, #5
L1:
    LCALL DELAY200ms
    DJNZ R3, L1
    RET

DELAY200ms:
    MOV R2, #200
L2:
    MOV R1, #200
L1_1:
    NOP
    NOP
    NOP
    DJNZ R1, L1_1
    DJNZ R2, L2
    RET

END
